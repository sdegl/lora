# Keil uVision project prj.uvprojx, settings and files
target RWC (6150000::V6.15::ARMCLANG)
  device: STM32WLE5CCUx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: RWC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL55xx,CORE_CM4
  c include: ..\code\cmsis\Core\Include;..\code\cmsis\Device\ST\STM32WLxx\Include;..\code\user\inc;..\code\stm32hal\inc;..\code\driver\inc;..\code\SubGHz_Phy\inc;..\code\utilities\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  group USER
    ../code/user/src/: main.c timer_if.c stm32wlxx_it.c subghz_app.c stm32_lpm_if.c
    ../code/user/inc/: stm32wlxx_hal_conf.h test.h
  group STM32HAL
    ../code/stm32hal/src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_comp.c stm32wlxx_hal_cortex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_dac.c stm32wlxx_hal_dac_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_gtzc.c stm32wlxx_hal_hsem.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_i2s.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_irda.c stm32wlxx_hal_iwdg.c stm32wlxx_hal_lptim.c stm32wlxx_hal_pka.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rng.c stm32wlxx_hal_rng_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_smartcard.c stm32wlxx_hal_smartcard_ex.c stm32wlxx_hal_smbus.c stm32wlxx_hal_spi.c stm32wlxx_hal_spi_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_usart.c stm32wlxx_hal_usart_ex.c stm32wlxx_hal_wwdg.c stm32wlxx_ll_adc.c stm32wlxx_ll_comp.c stm32wlxx_ll_crc.c stm32wlxx_ll_dac.c stm32wlxx_ll_dma.c stm32wlxx_ll_exti.c stm32wlxx_ll_gpio.c stm32wlxx_ll_i2c.c stm32wlxx_ll_lptim.c stm32wlxx_ll_lpuart.c stm32wlxx_ll_pka.c stm32wlxx_ll_pwr.c stm32wlxx_ll_rcc.c stm32wlxx_ll_rng.c stm32wlxx_ll_rtc.c stm32wlxx_ll_spi.c stm32wlxx_ll_tim.c stm32wlxx_ll_usart.c stm32wlxx_ll_utils.c
  group DEVICE
    ../code/cmsis/Device/ST/STM32WLxx/Source/: system_stm32wlxx.c
    ../code/cmsis/Device/ST/STM32WLxx/Source/arm/: startup_stm32wl55xx_cm4.s
  group DRIVER
    ../code/driver/src/: rtc.c subghz.c led.c key.c
    ../code/SubGHz_Phy/src/: radio.c radio_driver.c radio_board_if.c
  group UTILITIES
    ../code/utilities/src/: stm32_timer.c stm32_mem.c stm32_systime.c stm32_lpm.c
